# Keil uVision project MassStorage.uvprojx, settings and files
target Debug (6140001::V6.14.1::ARMCLANG)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0-dev0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x2003e000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x3e000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: MassStorage.c USBD_User_MSC_0.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L496AGIx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L496AGIx/STCubeGenerated/Inc/: stm32l4xx_it.h
target Release (6140001::V6.14.1::ARMCLANG)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0-dev0
  cpu: as above
  output: MassStorage
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, File System:CORE 6.13.8, File System:CORE 6.13.8, File System:Drive:Memory Card 6.13.8, USB:CORE 6.14.1, USB:CORE 6.14.1, USB:Device 6.14.1, USB:Device:MSC 6.14.1, CMSIS Driver:MCI 1.3.0, CMSIS Driver:USB Device:Full-speed 1.3.0, Device:STM32Cube HAL:Common 1.12.0, Device:STM32Cube HAL:Cortex 1.12.0, Device:STM32Cube HAL:DMA 1.12.0, Device:STM32Cube HAL:GPIO 1.12.0, Device:STM32Cube HAL:MMC 1.10.0, Device:STM32Cube HAL:PCD 1.12.0, Device:STM32Cube HAL:PWR 1.12.0, Device:STM32Cube HAL:RCC 1.12.0, Device:STM32Cube HAL:SD 1.12.0, Device:Startup 1.3.1
