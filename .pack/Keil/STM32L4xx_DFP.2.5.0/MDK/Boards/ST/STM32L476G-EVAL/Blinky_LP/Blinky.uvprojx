# Keil uVision project Blinky.uvprojx, settings and files
target Debug (6140001::V6.14.1::ARMCLANG)
  device: STM32L476ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0-dev0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_IOEXPANDER USE_STM32L476G_EVAL_REVB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20016000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x16000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source
    ./: Blinky.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L476ZGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L476ZGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group Documentation
    ./: Abstract.txt
target Release (6140001::V6.14.1::ARMCLANG)
  device: STM32L476ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0-dev0
  cpu: as above
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_IOEXPANDER USE_STM32L476G_EVAL_REVB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Board Support:A/D Converter 1.0.0, Board Support:Buttons 1.0.0, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:I/O 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube HAL:ADC 1.12.0, Device:STM32Cube HAL:Common 1.12.0, Device:STM32Cube HAL:Cortex 1.12.0, Device:STM32Cube HAL:DMA 1.12.0, Device:STM32Cube HAL:GPIO 1.12.0, Device:STM32Cube HAL:I2C 1.12.0, Device:STM32Cube HAL:PWR 1.12.0, Device:STM32Cube HAL:RCC 1.12.0, Device:STM32Cube HAL:RTC 1.12.0, Device:STM32Cube HAL:SRAM 1.12.0, Device:Startup 1.3.1
