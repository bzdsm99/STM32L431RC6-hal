# Keil uVision project STM32L4P5G_Disco_PSRAM.uvprojx, settings and files
target STM32L4P5G_DK_PSRAM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: APS6408L-3OB_STM32L4P5G-DK
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FLASH_MEM,USE_HAL_DRIVER,STM32L4P5xx,USE_IOEXPANDER, CORE_CM4
  c include: ./;.\PSRAM;..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Drivers\CMSIS\Core\Include;..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\STM32L4P5G-Discovery;..\..\..\Drivers\BSP\Components
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group OSPI
    ./PSRAM/: STM32L4PSRAM.c stm32l4p5g_discovery_psram.c
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_ospi.c stm32l4xx_ll_fmc.c
    ../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
