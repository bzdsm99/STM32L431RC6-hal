# Keil uVision project STM32L4P5xx.uvprojx, settings and files
target STM32L4P5xx_1M (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: STM32L4P5xx_1M
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM STM32L4P5xx_1M
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32L4P5xx_512 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: STM32L4P5xx_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM STM32L4P5xx_512
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
