# Keil uVision project STM32L476G_DISCO-QSPI.uvprojx, settings and files
target STM32L476G-Disco_QSPI (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: N25Q128A_STM32L476-Disco
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1
  c define: FLASH_MEM,USE_HAL_DRIVER,STM32L476xx,USE_IOEXPANDER, CORE_CM4
  c include: ./;.\QSPI;..\..\..\Drivers\BSP\STM32L476G-Discovery;..\..\..\Drivers\BSP\Components\n25q128a;..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x24000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group QSPI
    ./QSPI/: STM32L4QSPI.c stm32l476g_discovery_qspi.c
    ../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c
